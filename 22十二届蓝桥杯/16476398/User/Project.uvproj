# Keil uVision project Project.uvproj, settings and files
target 10蓝桥杯LED模块 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Diver
  group User
    ./: main.c
  group Diver
    ../Diver/: Key.c Key.h Seg.c Seg.h Init.c Init.h Led.c Led.h ds1302.c onewire.c onewire.h iic.c
    ./: ds1302.h iic.h
