# Keil uVision project Project.uvproj, settings and files
target 十一届蓝桥杯 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Diver
  group User
    ./: main.c
  group Diver
    ../Diver/: ds1302.c ds1302.h iic.c iic.h Init.c Init.h Key.c Key.h Led.c Led.h onewire.c onewire.h Seg.c Seg.h
